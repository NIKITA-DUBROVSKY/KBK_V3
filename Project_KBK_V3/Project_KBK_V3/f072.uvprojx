# Keil uVision project f072.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F072CBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: f072 +hex
  AfterMake: ".\crc_keil.bat"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F072xB
  c include: .\STM32F0xx_StdPeriph_Lib_V1.5.0\Libraries\CMSIS\Device\ST\STM32F0xx\Include;.\STM32F0xx_StdPeriph_Lib_V1.5.0\Libraries\CMSIS\Device\ST\STM32F0xx\Source;.\STM32F0xx_StdPeriph_Lib_V1.5.0\Libraries\STM32F0xx_StdPeriph_Driver\inc;.\STM32F0xx_StdPeriph_Lib_V1.5.0\Libraries\STM32F0xx_StdPeriph_Driver\src;.\user\Inc;.\user\SPI_SD_Card;.\user\FATFS_V0.08A\src;.\USB;.\USB\CDC;.\USB\Core;.\USB\MSC;.\USB\MSC_CDC;.\USB\stm32f0xx_hal;.\STM32_Cryptographic_Library\inc;.\STM32_Cryptographic_Library\inc\HASH\MD5;.\BOOTLOADER\user
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x1c000
  memory RVCT9: RAM 0x200000c4 size 0x3f3c
  group user
    ./: main.c
    ./user/: ADC.c buttons.c CAN.c i2c.c led.c MicroMenu.c timers.c messages.c AT45DB.c
    ./BOOTLOADER/user/: hd44780.c
  group SPL
    ./STM32F0xx_StdPeriph_Lib_V1.5.0/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_dma.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_spi.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_iwdg.c stm32f0xx_syscfg.c stm32f0xx_crc.c
  group FATFS
    ./user/SPI_SD_Card/: SPI_MSD_Driver.c
    ./user/FATFS_V0.08A/src/: diskio.c ff.c
  group USB
    ./USB/: usbd_storage_if.c
    ./USB/MSC_CDC/: usbd_msc_cdc.c
    ./USB/MSC/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
    ./USB/Core/: usbd_conf.c usbd_core.c usbd_ctlreq.c usbd_desc.c usbd_ioreq.c
    ./USB/CDC/: usbd_cdc.c usbd_cdc_if.c
    ./USB/stm32f0xx_hal/: stm32f0xx_hal_pcd.c stm32f0xx_hal_pcd_ex.c stm32f0xx_ll_usb.c
  group STM32_Cryptographic_Lib
    ./STM32_Cryptographic_Library/binary/MK-ARM/: M0_CryptoFW_2_0_6.lib
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.0
